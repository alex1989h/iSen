# Keil uVision project ISenPraktikum2.uvproj, settings and files
target ISenPraktikum2 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F417ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Anwendung
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c misc: --c99
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group TI-C_Board
    ./: startup_stm32f4xx.s TI_Lib.c Usart.c Retarget.c TI_Board_IO.c tft.c TI_Board_ADC.c TI_BOARD_ADC.h
  group USER
    ./: stm32f4xx_it.c main.c
  group CMSIS
    ./: system_stm32f4xx.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c misc.c stm32f4xx_adc.c stm32f4xx_dma.c
  group Header
    ./: main.h stm32f4xx_adc.h stm32f4xx_dma.h
